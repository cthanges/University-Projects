# Keil uVision project finalproject_mediacenter.uvproj, settings and files
target LPC1700 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: finalproject_mediacenter
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Code
    ./: core_cm3.c GLCD_SPI_LPC1700.c IRQ.c LED.c KBD.c Media_Center.c
  group Image Files
    ./Images/: GKMC.c MMLP.c Joey1999.c Madvillainy.c
  group Media Center
    ./: Photo_Gallery.c Photo_Viewer.c Game.c
  group Audio
    ./: usbdmain.c adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Game Images
    ./: blocks.c
    ./Images/: Mario.c MarioIntro.c
